SUMMARY = "Cryptographic library for Python"
HOMEPAGE = "https://www.pycryptodome.org"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=accfa6aeaceb3ba96676edf18e78302c"

SRC_URI[md5sum] = "91b86ca7fa80d41179d7735067c7347a"
SRC_URI[sha256sum] = "541cd3e3e252fb19a7b48f420b798b53483302b7fe4d9954c947605d0a263d62"

PYPI_PACKAGE = "pycryptodomex"
PYPI_PACKAGE_EXT = "tar.gz"

inherit pypi setuptools3
