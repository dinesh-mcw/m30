SUMMARY = "Parameterized testing with any Python test framework"
HOMEPAGE = "https://github.com/wolever/parameterized"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=48fe232078ad0267828f319bd8b8ab2e"

SRC_URI[md5sum] = "a4c7408fffd7a16c2c0695dc8d588372"
SRC_URI[sha256sum] = "d8c8837fb677ed2d5a93b9e2308ce0da3aeb58cf513120d501e0b7af14da78d5"

PYPI_PACKAGE = "parameterized"
PYPI_PACKAGE_EXT = "tar.gz"

inherit pypi setuptools3
