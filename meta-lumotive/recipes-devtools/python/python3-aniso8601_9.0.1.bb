SUMMARY = "A library for parsing ISO 8601 strings."
HOMEPAGE = "https://bitbucket.org/nielsenb/aniso8601"
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=6d91d56f51a54389d95526eefe039b1c"

SRC_URI[md5sum] = "89b25ea9fd70b8facaf189aed43afcf8"
SRC_URI[sha256sum] = "72e3117667eedf66951bb2d93f4296a56b94b078a8a95905a052611fb3f1b973"

PYPI_PACKAGE = "aniso8601"
PYPI_PACKAGE_EXT = "tar.gz"

inherit pypi setuptools3
